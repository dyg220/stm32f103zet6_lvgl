# Keil uVision project lvgl_Register.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_LED_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LV_CONF_INCLUDE_SIMPLE
  c include: .\Start;.\User;.\Driver\usart;.\Driver\fsmc;.\Driver\i2c;.\Driver\timer;.\Inf\lcd;.\Inf\FT5x16;.\app\display;.\Common\debug;.\Common\delay;.\mid\lvgl\porting;.\mid\lvgl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c
  group Driver
    ./Driver/usart/: Driver_USART.c
    ./Driver/fsmc/: Driver_FSMC.c
    ./Driver/i2c/: Driver_I2C1.c
    ./Driver/timer/: Driver_TIM6.c
  group Inf
    ./Inf/lcd/: Inf_LCD.c
    ./Inf/FT5x16/: Inf_FT5x16.c
  group App
    ./app/display/: App_DisplayDemo.c
  group Common
    ./Common/debug/: Common_Debug.c Common_Debug.h
    ./Common/delay/: Common_Delay.c
  group mid/lvgl/src
    mid/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    mid/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    mid/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    mid/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    mid/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    mid/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    mid/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    mid/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    mid/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    mid/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    mid/lvgl/src/extra/: lv_extra.c
    mid/lvgl/src/extra/layouts/flex/: lv_flex.c
    mid/lvgl/src/extra/layouts/grid/: lv_grid.c
    mid/lvgl/src/extra/libs/bmp/: lv_bmp.c
    mid/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    mid/lvgl/src/extra/libs/freetype/: lv_freetype.c
    mid/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    mid/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    mid/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    mid/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    mid/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    mid/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    mid/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    mid/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    mid/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    mid/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    mid/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    mid/lvgl/src/extra/others/monkey/: lv_monkey.c
    mid/lvgl/src/extra/others/msg/: lv_msg.c
    mid/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    mid/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    mid/lvgl/src/extra/themes/default/: lv_theme_default.c
    mid/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    mid/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    mid/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    mid/lvgl/src/extra/widgets/chart/: lv_chart.c
    mid/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    mid/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    mid/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    mid/lvgl/src/extra/widgets/led/: lv_led.c
    mid/lvgl/src/extra/widgets/list/: lv_list.c
    mid/lvgl/src/extra/widgets/menu/: lv_menu.c
    mid/lvgl/src/extra/widgets/meter/: lv_meter.c
    mid/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    mid/lvgl/src/extra/widgets/span/: lv_span.c
    mid/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    mid/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    mid/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    mid/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    mid/lvgl/src/extra/widgets/win/: lv_win.c
    mid/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    mid/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    mid/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    mid/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group mid/lvgl/porting
    mid/lvgl/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
  group mid/lvgl
    ./mid/lvgl/: lv_conf.h lvgl.h
